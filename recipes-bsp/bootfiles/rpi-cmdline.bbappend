CMDLINE_ROOT_PARTITION = "/dev/sda2"