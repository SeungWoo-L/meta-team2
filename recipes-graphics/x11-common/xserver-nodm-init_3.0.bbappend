PACKAGECONFIG:append = " nocursor"
